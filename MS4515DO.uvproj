# Keil uVision project MS4515DO.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: MS4515DO +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c STARTUP.A51
  group source
    ./: LCD12864.c ziku.c Display.c global_var.c key.c storage.c eeprom.c SPD6000.C pwm.c MS4525.c CH4.C
